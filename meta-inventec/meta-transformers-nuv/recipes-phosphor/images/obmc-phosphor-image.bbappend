inherit buv-image


OBMC_IMAGE_EXTRA_INSTALL_append += " transformers-init"
