SRC_URI_transformers-nuv := "git://github.com/Nuvoton-Israel/pmci.git;protocol=ssh"
SRCREV_transformers-nuv := "bbbe833676c74b61fdc7bcc67d756eb8f557641a"
