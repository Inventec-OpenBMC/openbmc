FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Bug-713-SW-Common-phosphor-nvme-Remove-the-dbus-sens.patch \
           "


