PHOSPHOR_DBUS_MONITOR_CONFIGS_append_goldentalon = " events-policy"
PHOSPHOR_DBUS_MONITOR_CONFIGS_append_transformers = " events-policy"
