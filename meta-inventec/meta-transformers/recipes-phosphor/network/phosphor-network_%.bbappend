FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-inventec-Add-hook-to-mACAddress-to-call-mac_util.patch"

