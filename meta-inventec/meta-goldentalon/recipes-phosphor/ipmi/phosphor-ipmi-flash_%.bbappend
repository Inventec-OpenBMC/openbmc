IPMI_FLASH_BMC_ADDRESS = "0x9f7c0000"
