FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"

SRC_URI_append = " \
	file://0001-Add-property-EepromPath-and-EepromService-under-xyz..patch \
" 
