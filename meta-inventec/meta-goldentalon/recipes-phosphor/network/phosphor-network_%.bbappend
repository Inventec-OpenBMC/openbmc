FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Write-MAC-address-to-BMC-EEPROM.patch"

